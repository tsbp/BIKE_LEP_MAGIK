<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BIKE_LEP_MAGIK.ewp</path>
  </project>
  <batchBuild/>
</workspace>


